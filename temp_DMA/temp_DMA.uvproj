# Keil uVision project temp_DMA.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: temp_DMA +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\temp_DMA;..\..\CORE;..\..\STM32_FWLIB\inc;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\USER;..\..\SYSTEM\usart;.\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ../../USER/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./: main.c
  group CORE
    ../../CORE/: core_cm3.c core_cm3.h
  group FWLIB
    ../../STM32_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_bkp.c
  group SYSTEM
    ../../SYSTEM/sys/: sys.c
    ./: temDMA.c
    ../../SYSTEM/delay/: delay.c
    ./usart/: usart.c
