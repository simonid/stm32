# Keil uVision project dht11.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dht11 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\STM32_FWLIB\inc;..\..\STM32_FWLIB\src;..\..\CORE;..\..\SYSTEM\DHT11;..\..\SYSTEM\sys;..\..\SYSTEM\delay;..\..\USER;..\dht11;..\..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ../../USER/: system_stm32f10x.h system_stm32f10x.c stm32f10x_it.h stm32f10x_it.c stm32f10x_conf.h stm32f10x.h
    ./: main.c
  group SYSTEM
    ../../SYSTEM/DHT11/: dht11.c dht11.h
    ../../SYSTEM/delay/: delay.c delay.h
    ../../SYSTEM/sys/: sys.c sys.h
    ../../SYSTEM/usart/: usart.c usart.h
    ./: ds18b20.c ds18b20.h
  group CORE
    ../../CORE/: core_cm3.c core_cm3.h
  group FWLIB
    ../../STM32_FWLIB/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../STM32_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
